# Keil uVision project H743_LCD_Keil5.uvprojx, settings and files
target H743_LCD_Keil5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H743_LCD_Keil5 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_PWR_LDO_SUPPLY,LV_CONF_INCLUDE_SIMPLE,ARM_MATH_MATRIX,ARM_MATH_LOOPUNROLL,ARM_MATH_CM7,__TARGET_FPU_VFP,HAL_DAC_MODULE_ENABLED
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../lvgl;../lvgl_GUI/generated;../lvgl_GUI/custom;../lvgl/src;../lvgl/porting;../Core/Peripheral/Inc;../Core/Peripheral/MP3/Helix;../Core/Application/Inc;../Core/Middlewares/FATFS;../Core/Middlewares/MJPEG;../Core/Middlewares/NES;../Utilities/JPEG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\H743_LCD_Keil5\H743_LCD_Keil5_custom.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: touch_i2c.c gt9xxx.c hander.c main.c gpio.c adc.c dma.c dma2d.c fmc.c i2c.c jpeg.c ltdc.c quadspi.c rtc.c sai.c sdmmc.c spdifrx.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group LVGL_CORE
    ../lvgl/src/core/: lv_global.h lv_group.c lv_group.h lv_group_private.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_class_private.h lv_obj_draw.c lv_obj_draw.h lv_obj_draw_private.h lv_obj_event.c lv_obj_event.h lv_obj_event_private.h lv_obj_id_builtin.c lv_obj_pos.c lv_obj_pos.h lv_obj_private.h lv_obj_property.c lv_obj_property.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_scroll_private.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_style_private.h lv_obj_tree.c lv_obj_tree.h lv_observer.c lv_observer.h lv_observer_private.h lv_refr.c lv_refr.h lv_refr_private.h
    ../lvgl/src/debugging/monkey/: lv_monkey.c lv_monkey.h lv_monkey_private.h
    ../lvgl/src/debugging/sysmon/: lv_sysmon.c lv_sysmon.h lv_sysmon_private.h
    ../lvgl/src/debugging/test/: lv_test.h lv_test_display.c lv_test_display.h lv_test_fs.c lv_test_fs.h lv_test_helpers.c lv_test_helpers.h lv_test_indev.c lv_test_indev.h lv_test_indev_gesture.c lv_test_indev_gesture.h lv_test_private.h lv_test_screenshot_compare.c lv_test_screenshot_compare.h
    ../lvgl/src/debugging/vg_lite_tvg/: vg_lite.h vg_lite_matrix.c vg_lite_tvg.cpp
    ../lvgl/src/display/: lv_display.c lv_display.h lv_display_private.h
    ../lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c lv_draw_buf_convert_helium.h
    ../lvgl/src/draw/convert/: lv_draw_buf_convert.c lv_draw_buf_convert.h
    ../lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c lv_draw_buf_convert_neon.h
    ../lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d.h lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d_private.h
    ../lvgl/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa.h lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c lv_draw_ppa_private.h
    ../lvgl/src/draw/eve/: lv_draw_eve.c lv_draw_eve.h lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_private.h lv_draw_eve_ram_g.c lv_draw_eve_ram_g.h lv_draw_eve_target.h lv_draw_eve_triangle.c lv_eve.c lv_eve.h
    ../lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_3d.c lv_draw_3d.h lv_draw_arc.c lv_draw_arc.h lv_draw_blur.c lv_draw_blur.h lv_draw_buf.c lv_draw_buf.h lv_draw_buf_private.h lv_draw_image.c lv_draw_image.h lv_draw_image_private.h lv_draw_label.c lv_draw_label.h lv_draw_label_private.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_private.h lv_draw_rect.c lv_draw_rect.h lv_draw_rect_private.h lv_draw_triangle.c lv_draw_triangle.h lv_draw_triangle_private.h lv_draw_vector.c lv_draw_vector.h lv_draw_vector_private.h lv_image_decoder.c lv_image_decoder.h lv_image_decoder_private.h lv_image_dsc.h
    ../lvgl/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg.h lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_private.h lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_fbo_cache.h lv_nanovg_image_cache.c lv_nanovg_image_cache.h lv_nanovg_math.h lv_nanovg_utils.c lv_nanovg_utils.h
    ../lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx.h lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_utils.h lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c lv_nema_gfx_path.h
    ../lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d.h lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_buf_map.h lv_g2d_utils.c lv_g2d_utils.h
    ../lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_cfg.h lv_pxp_osa.c lv_pxp_osa.h lv_pxp_utils.c lv_pxp_utils.h
    ../lvgl/src/draw/opengles/: lv_draw_opengles.c lv_draw_opengles.h
    ../lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d.h lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c lv_draw_dave2d_utils.h
    ../lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h
    ../lvgl/src/draw/snapshot/: lv_snapshot.c lv_snapshot.h
    ../lvgl/src/draw/sw/arm2d/: lv_draw_sw_arm2d.h lv_draw_sw_helium.h
    ../lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.h
    ../lvgl/src/draw/sw/blend/helium/: lv_blend_helium.h lv_blend_helium.S
    ../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_blend_private.h lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_a8.h lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_al88.h lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888.h lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888_premultiplied.h lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_i1.h lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_l8.h lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565.h lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565_swapped.h lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend_to_rgb888.h
    ../lvgl/src/draw/sw/blend/neon/: lv_blend_neon.h lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb565.h lv_draw_sw_blend_neon_to_rgb888.c lv_draw_sw_blend_neon_to_rgb888.h
    ../lvgl/src/draw/sw/blend/riscv_v/: lv_blend_riscv_v.h lv_blend_riscv_v_private.h lv_blend_riscv_vector_emulation.h lv_draw_sw_blend_riscv_v_to_rgb888.c lv_draw_sw_blend_riscv_v_to_rgb888.h
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_grad.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask.h lv_draw_sw_mask_private.h lv_draw_sw_mask_rect.c lv_draw_sw_private.h lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_utils.h lv_draw_sw_vector.c
    ../lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite.h lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_type.h lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_bitmap_font_cache.h lv_vg_lite_decoder.c lv_vg_lite_decoder.h lv_vg_lite_grad.c lv_vg_lite_grad.h lv_vg_lite_math.c lv_vg_lite_math.h lv_vg_lite_path.c lv_vg_lite_path.h lv_vg_lite_pending.c lv_vg_lite_pending.h lv_vg_lite_stroke.c lv_vg_lite_stroke.h lv_vg_lite_utils.c lv_vg_lite_utils.h
    ../lvgl/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm.h lv_linux_drm_common.c lv_linux_drm_egl.c lv_linux_drm_egl_private.h
    ../lvgl/src/drivers/display/fb/: lv_linux_fbdev.c lv_linux_fbdev.h
    ../lvgl/src/drivers/display/ft81x/: lv_ft81x.c lv_ft81x.h lv_ft81x_defines.h
    ../lvgl/src/drivers/display/ili9341/: lv_ili9341.c lv_ili9341.h
    ../lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c lv_lcd_generic_mipi.h
    ../lvgl/src/drivers/display/lovyan_gfx/: lv_lgfx_user.hpp lv_lovyan_gfx.cpp lv_lovyan_gfx.h
    ../lvgl/src/drivers/display/nv3007/: lv_nv3007.c lv_nv3007.h
    ../lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c lv_nxp_elcdif.h
    ../lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c lv_renesas_glcdc.h
    ../lvgl/src/drivers/display/st7735/: lv_st7735.c lv_st7735.h
    ../lvgl/src/drivers/display/st7789/: lv_st7789.c lv_st7789.h
    ../lvgl/src/drivers/display/st7796/: lv_st7796.c lv_st7796.h
    ../lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c lv_st_ltdc.h
    ../lvgl/src/drivers/display/tft_espi/: lv_tft_espi.cpp lv_tft_espi.h
    ../lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c lv_draw_eve_display.h lv_draw_eve_display_defines.h
    ../lvgl/src/drivers/evdev/: lv_evdev.c lv_evdev.h lv_evdev_private.h
    ../lvgl/src/drivers/libinput/: lv_libinput.c lv_libinput.h lv_libinput_private.h lv_xkb.c lv_xkb.h lv_xkb_private.h
    ../lvgl/src/drivers/: lv_drivers.h README.md
    ../lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c lv_opengles_shader.h
    ../lvgl/src/drivers/opengles/glad/include/EGL/: eglplatform.h
    ../lvgl/src/drivers/opengles/glad/include/glad/: egl.h gl.h gles2.h
    ../lvgl/src/drivers/opengles/glad/include/KHR/: khrplatform.h
    ../lvgl/src/drivers/opengles/glad/: README.md
    ../lvgl/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    ../lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_debug.h lv_opengles_driver.c lv_opengles_driver.h lv_opengles_egl.c lv_opengles_egl.h lv_opengles_egl_private.h lv_opengles_glfw.c lv_opengles_glfw.h lv_opengles_private.h lv_opengles_texture.c lv_opengles_texture.h lv_opengles_texture_private.h lv_opengles_window.h
    ../lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_internal.h lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../lvgl/src/drivers/qnx/: lv_qnx.c lv_qnx.h
    ../lvgl/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_keyboard.h lv_sdl_mouse.c lv_sdl_mouse.h lv_sdl_mousewheel.c lv_sdl_mousewheel.h lv_sdl_private.h lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c lv_sdl_window.h
    ../lvgl/src/drivers/uefi/: lv_uefi.h lv_uefi_context.c lv_uefi_context.h lv_uefi_display.c lv_uefi_display.h lv_uefi_edk2.h lv_uefi_gnu_efi.h lv_uefi_indev.h lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c lv_uefi_private.h lv_uefi_std_wrapper.h
    ../lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland.h lv_wayland_backend_egl.c lv_wayland_backend_g2d.c lv_wayland_backend_private.h lv_wayland_backend_shm.c lv_wayland_keyboard.c lv_wayland_keyboard.h lv_wayland_pointer.c lv_wayland_pointer.h lv_wayland_pointer_axis.h lv_wayland_private.h lv_wayland_seat.c lv_wayland_touch.c lv_wayland_touch.h lv_wayland_window.c lv_wayland_window.h lv_wayland_xdg_shell.c
    ../lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_context.h lv_windows_display.c lv_windows_display.h lv_windows_input.c lv_windows_input.h lv_windows_input_private.h
    ../lvgl/src/drivers/x11/: lv_x11.h lv_x11_display.c lv_x11_input.c
    ../lvgl/src/font/binfont_loader/: lv_binfont_loader.c lv_binfont_loader.h
    ../lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_fmt_txt_private.h
    ../lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager.h lv_font_manager_recycle.c lv_font_manager_recycle.h
    ../lvgl/src/font/imgfont/: lv_imgfont.c lv_imgfont.h
    ../lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_private.h lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h lv_font_montserrat_12_subpx.c
    ../lvgl/src/indev/: lv_gridnav.c lv_gridnav.h lv_indev.c lv_indev.h lv_indev_gesture.c lv_indev_gesture.h lv_indev_gesture_private.h lv_indev_private.h lv_indev_scroll.c lv_indev_scroll.h
    ../lvgl/src/layouts/flex/: lv_flex.c lv_flex.h
    ../lvgl/src/layouts/grid/: lv_grid.c lv_grid.h
    ../lvgl/src/layouts/: lv_layout.c lv_layout.h lv_layout_private.h
    ../lvgl/src/libs/barcode/: code128.c code128.h LICENSE.txt lv_barcode.c lv_barcode.h lv_barcode_private.h
    ../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c lv_bin_decoder.h
    ../lvgl/src/libs/bmp/: lv_bmp.c lv_bmp.h
    ../lvgl/src/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h lv_ffmpeg_private.h
    ../lvgl/src/libs/freetype/: freetype-LICENSE.txt ftmodule.h ftoption.h LiberationSans-LICENSE.txt LiberationSans-Regular.ttf lv_freetype.c lv_freetype.h lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype_private.h lv_ftsystem.c
    ../lvgl/src/libs/frogfs/include/frogfs/: frogfs.h frogfs_types.h
    ../lvgl/src/libs/frogfs/: LICENSE.txt
    ../lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c frogfs_format.h frogfs_priv.h
    ../lvgl/src/libs/fsdrv/: lv_fs_arduino_esp_littlefs.cpp lv_fs_arduino_sd.cpp lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c lv_fsdrv.h
    ../lvgl/src/libs/FT800-FT813/: EVE.h EVE_commands.c EVE_commands.h EVE_config.h EVE_supplemental.c EVE_suppplemental.h EVE_target.h LICENSE README.md
    ../lvgl/src/libs/gif/: AnimatedGIF.h gif.c LICENSE
    ../lvgl/src/libs/gltf/fastgltf/: lv_fastgltf.hpp
    ../lvgl/src/libs/gltf/gltf_data/: lv_gltf_data.cpp lv_gltf_data_animations.cpp lv_gltf_data_cache.cpp lv_gltf_data_injest.cpp lv_gltf_data_internal.h lv_gltf_data_internal.hpp lv_gltf_data_mesh.cpp lv_gltf_data_primitive.cpp lv_gltf_data_shader.cpp lv_gltf_data_skin.cpp lv_gltf_data_texture.cpp lv_gltf_model.h lv_gltf_model_loader.c lv_gltf_model_loader.h lv_gltf_model_node.cpp lv_gltf_model_node.h lv_gltf_uniform_locations.cpp
    ../lvgl/src/libs/gltf/gltf_environment/: lv_gltf_environment.h lv_gltf_environment_private.h lv_gltf_ibl_sampler.c
    ../lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c lv_gltf_view_shader.h
    ../lvgl/src/libs/gltf/gltf_view/: lv_gltf.h lv_gltf_view.cpp lv_gltf_view_internal.h lv_gltf_view_render.cpp lv_gltf_view_shader.cpp
    ../lvgl/src/libs/gltf/math/: lv_3dmath.c lv_3dmath.h lv_gltf_math.cpp lv_gltf_math.hpp
    ../lvgl/src/libs/gltf/stb_image/: stb_image.h
    ../lvgl/src/libs/gstreamer/: lv_gstreamer.c lv_gstreamer.h lv_gstreamer_internal.h
    ../lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c lv_libjpeg_turbo.h
    ../lvgl/src/libs/libpng/: lv_libpng.c lv_libpng.h
    ../lvgl/src/libs/libwebp/: lv_libwebp.c lv_libwebp.h
    ../lvgl/src/libs/lodepng/: lodepng.c lodepng.h lv_lodepng.c lv_lodepng.h
    ../lvgl/src/libs/lz4/: lz4.c lz4.h
    ../lvgl/src/libs/nanovg/: nanovg.c nanovg.h nanovg_gl.h nanovg_gl_utils.h
    ../lvgl/src/libs/qrcode/: lv_qrcode.c lv_qrcode.h lv_qrcode_private.h qrcodegen.c qrcodegen.h
    ../lvgl/src/libs/rle/: lv_rle.c lv_rle.h
    ../lvgl/src/libs/rlottie/: lv_rlottie.c lv_rlottie.h lv_rlottie_private.h
    ../lvgl/src/libs/svg/: lv_svg.c lv_svg.h lv_svg_decoder.c lv_svg_decoder.h lv_svg_parser.c lv_svg_parser.h lv_svg_render.c lv_svg_render.h lv_svg_token.c lv_svg_token.h
    ../lvgl/src/libs/thorvg/: add_lvgl_if.sh config.h thorvg.h thorvg_capi.h thorvg_lottie.h tvgAccessor.cpp tvgAnimation.cpp tvgAnimation.h tvgArray.h tvgBinaryDesc.h tvgCanvas.cpp tvgCanvas.h tvgCapi.cpp tvgCommon.h tvgCompressor.cpp tvgCompressor.h tvgFill.cpp tvgFill.h tvgFrameModule.h tvgGlCanvas.cpp tvgInitializer.cpp tvgInlist.h tvgIteratorAccessor.h tvgLoader.cpp tvgLoader.h tvgLoadModule.h tvgLock.h tvgLottieAnimation.cpp tvgLottieBuilder.cpp tvgLottieBuilder.h tvgLottieCommon.h tvgLottieExpressions.cpp tvgLottieExpressions.h tvgLottieInterpolator.cpp tvgLottieInterpolator.h tvgLottieLoader.cpp tvgLottieLoader.h tvgLottieModel.cpp tvgLottieModel.h tvgLottieModifier.cpp tvgLottieModifier.h tvgLottieParser.cpp tvgLottieParser.h tvgLottieParserHandler.cpp tvgLottieParserHandler.h tvgLottieProperty.h tvgLottieRenderPooler.h tvgMath.cpp tvgMath.h tvgPaint.cpp tvgPaint.h tvgPicture.cpp tvgPicture.h tvgRawLoader.cpp tvgRawLoader.h tvgRender.cpp tvgRender.h tvgSaveModule.h tvgSaver.cpp tvgScene.cpp tvgScene.h tvgShape.cpp tvgShape.h tvgStr.cpp tvgStr.h tvgSvgCssStyle.cpp tvgSvgCssStyle.h tvgSvgLoader.cpp tvgSvgLoader.h tvgSvgLoaderCommon.h tvgSvgPath.cpp tvgSvgPath.h tvgSvgSceneBuilder.cpp tvgSvgSceneBuilder.h tvgSvgUtil.cpp tvgSvgUtil.h tvgSwCanvas.cpp tvgSwCommon.h tvgSwFill.cpp tvgSwImage.cpp tvgSwMath.cpp tvgSwMemPool.cpp tvgSwPostEffect.cpp tvgSwRaster.cpp tvgSwRasterAvx.h tvgSwRasterC.h tvgSwRasterNeon.h tvgSwRasterTexmap.h tvgSwRenderer.cpp tvgSwRenderer.h tvgSwRle.cpp tvgSwShape.cpp tvgSwStroke.cpp tvgTaskScheduler.cpp tvgTaskScheduler.h tvgText.cpp tvgText.h tvgWgCanvas.cpp tvgXmlParser.cpp tvgXmlParser.h
    ../lvgl/src/libs/thorvg/rapidjson/: allocators.h cursorstreamwrapper.h document.h encodedstream.h encodings.h filereadstream.h filewritestream.h fwd.h istreamwrapper.h memorybuffer.h memorystream.h ostreamwrapper.h pointer.h prettywriter.h rapidjson.h reader.h schema.h stream.h stringbuffer.h uri.h writer.h
    ../lvgl/src/libs/thorvg/rapidjson/error/: en.h error.h
    ../lvgl/src/libs/thorvg/rapidjson/internal/: biginteger.h clzll.h diyfp.h dtoa.h ieee754.h itoa.h meta.h pow10.h regex.h stack.h strfunc.h strtod.h swap.h
    ../lvgl/src/libs/thorvg/rapidjson/msinttypes/: inttypes.h stdint.h
    ../lvgl/src/libs/tiny_ttf/: LICENSE.txt lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
    ../lvgl/src/libs/tjpgd/: LICENSE.txt lv_tjpgd.c lv_tjpgd.h tjpgd.c tjpgd.h tjpgdcnf.h
    ../lvgl/src/libs/vg_lite_driver/: add_lvgl_if.sh
    ../lvgl/src/libs/vg_lite_driver/inc/: vg_lite.h
    ../lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c vg_lite_platform.h
    ../lvgl/src/libs/vg_lite_driver/VGLite/Series/gc255/0x40A/: vg_lite_options.h
    ../lvgl/src/libs/vg_lite_driver/VGLite/Series/gc355/0x0_1215/: vg_lite_options.h
    ../lvgl/src/libs/vg_lite_driver/VGLite/Series/gc355/0x0_1216/: vg_lite_options.h
    ../lvgl/src/libs/vg_lite_driver/VGLite/Series/gc555/0x423/: vg_lite_options.h
    ../lvgl/src/libs/vg_lite_driver/VGLite/Series/gc555/0x423_ECO/: vg_lite_options.h
    ../lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_context.h vg_lite_image.c vg_lite_matrix.c vg_lite_options.h vg_lite_path.c vg_lite_stroke.c
    ../lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_debug.h vg_lite_hal.h vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h vg_lite_option.h vg_lite_type.h
    ../lvgl/src/: lv_api_map_v8.h lv_api_map_v9_0.h lv_api_map_v9_1.h lv_api_map_v9_2.h lv_api_map_v9_3.h lv_api_map_v9_4.h lv_api_map_v9_5.h lv_conf_internal.h lv_conf_kconfig.h lv_init.c lv_init.h lvgl.h lvgl_private.h
    ../lvgl/src/misc/cache/class/: lv_cache_class.h lv_cache_lru_ll.c lv_cache_lru_ll.h lv_cache_lru_rb.c lv_cache_lru_rb.h lv_cache_sc_da.c lv_cache_sc_da.h
    ../lvgl/src/misc/cache/instance/: lv_cache_instance.h lv_image_cache.c lv_image_cache.h lv_image_header_cache.c lv_image_header_cache.h
    ../lvgl/src/misc/cache/: lv_cache.c lv_cache.h lv_cache_entry.c lv_cache_entry.h lv_cache_entry_private.h lv_cache_private.h
    ../lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_private.h lv_anim_timeline.c lv_anim_timeline.h lv_anim_timeline_private.h lv_area.c lv_area.h lv_area_private.h lv_array.c lv_array.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_bidi_private.h lv_check_arg.h lv_circle_buf.c lv_circle_buf.h lv_color.c lv_color.h lv_color_op.c lv_color_op.h lv_color_op_private.h lv_event.c lv_event.h lv_event_private.h lv_ext_data.h lv_fs.c lv_fs.h lv_fs_private.h lv_grad.c lv_grad.h lv_iter.c lv_iter.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_matrix.c lv_matrix.h lv_palette.c lv_palette.h lv_pending.c lv_pending.h lv_profiler.h lv_profiler_builtin.c lv_profiler_builtin.h lv_profiler_builtin_posix.c lv_profiler_builtin_private.h lv_rb.c lv_rb.h lv_rb_private.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_style_private.h lv_templ.c lv_templ.h lv_text.c lv_text.h lv_text_ap.c lv_text_ap.h lv_text_private.h lv_timer.c lv_timer.h lv_timer_private.h lv_tree.c lv_tree.h lv_types.h lv_utils.c lv_utils.h
    ../lvgl/src/osal/: lv_cmsis_rtos2.c lv_cmsis_rtos2.h lv_freertos.c lv_freertos.h lv_linux.c lv_linux.h lv_mqx.c lv_mqx.h lv_os.c lv_os.h lv_os_none.c lv_os_none.h lv_os_private.h lv_pthread.c lv_pthread.h lv_rtthread.c lv_rtthread.h lv_sdl2.c lv_sdl2.h lv_windows.c lv_windows.h
    ../lvgl/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h lv_file_explorer_private.h
    ../lvgl/src/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c lv_fragment_private.h
    ../lvgl/src/others/translation/: lv_translation.c lv_translation.h lv_translation_private.h
    ../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c lv_tlsf.h lv_tlsf_private.h
    ../lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../lvgl/src/stdlib/: lv_mem.c lv_mem.h lv_mem_private.h lv_sprintf.h lv_string.h
    ../lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../lvgl/src/themes/default/: lv_theme_default.c lv_theme_default.h
    ../lvgl/src/themes/: lv_theme.c lv_theme.h lv_theme_private.h
    ../lvgl/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ../lvgl/src/themes/simple/: lv_theme_simple.c lv_theme_simple.h
    ../lvgl/src/tick/: lv_tick.c lv_tick.h lv_tick_private.h
    ../lvgl/src/widgets/3dtexture/: lv_3dtexture.c lv_3dtexture.h lv_3dtexture_private.h
    ../lvgl/src/widgets/animimage/: lv_animimage.c lv_animimage.h lv_animimage_private.h
    ../lvgl/src/widgets/arc/: lv_arc.c lv_arc.h lv_arc_private.h
    ../lvgl/src/widgets/arclabel/: lv_arclabel.c lv_arclabel.h lv_arclabel_private.h
    ../lvgl/src/widgets/bar/: lv_bar.c lv_bar.h lv_bar_private.h
    ../lvgl/src/widgets/button/: lv_button.c lv_button.h lv_button_private.h
    ../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c lv_buttonmatrix.h lv_buttonmatrix_private.h
    ../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_chinese.c lv_calendar_chinese.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h lv_calendar_private.h
    ../lvgl/src/widgets/canvas/: lv_canvas.c lv_canvas.h lv_canvas_private.h
    ../lvgl/src/widgets/chart/: lv_chart.c lv_chart.h lv_chart_private.h
    ../lvgl/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h lv_checkbox_private.h
    ../lvgl/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h lv_dropdown_private.h
    ../lvgl/src/widgets/gif/: lv_gif.c lv_gif.h
    ../lvgl/src/widgets/image/: lv_image.c lv_image.h lv_image_private.h
    ../lvgl/src/widgets/imagebutton/: lv_imagebutton.c lv_imagebutton.h lv_imagebutton_private.h
    ../lvgl/src/widgets/ime/: lv_ime_pinyin.c lv_ime_pinyin.h lv_ime_pinyin_private.h
    ../lvgl/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h lv_keyboard_private.h
    ../lvgl/src/widgets/label/: lv_label.c lv_label.h lv_label_private.h
    ../lvgl/src/widgets/led/: lv_led.c lv_led.h lv_led_private.h
    ../lvgl/src/widgets/line/: lv_line.c lv_line.h lv_line_private.h
    ../lvgl/src/widgets/list/: lv_list.c lv_list.h
    ../lvgl/src/widgets/lottie/: lv_lottie.c lv_lottie.h lv_lottie_private.h
    ../lvgl/src/widgets/menu/: lv_menu.c lv_menu.h lv_menu_private.h
    ../lvgl/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h lv_msgbox_private.h
    ../lvgl/src/widgets/objx_templ/: lv_objx_templ.c lv_objx_templ.h
    ../lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_obj_property_names.h lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_style_properties.h lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../lvgl/src/widgets/roller/: lv_roller.c lv_roller.h lv_roller_private.h
    ../lvgl/src/widgets/scale/: lv_scale.c lv_scale.h lv_scale_private.h
    ../lvgl/src/widgets/slider/: lv_slider.c lv_slider.h lv_slider_private.h
    ../lvgl/src/widgets/span/: lv_span.c lv_span.h lv_span_private.h
    ../lvgl/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h lv_spinbox_private.h
    ../lvgl/src/widgets/spinner/: lv_spinner.c lv_spinner.h lv_spinner_private.h
    ../lvgl/src/widgets/switch/: lv_switch.c lv_switch.h lv_switch_private.h
    ../lvgl/src/widgets/table/: lv_table.c lv_table.h lv_table_private.h
    ../lvgl/src/widgets/tabview/: lv_tabview.c lv_tabview.h lv_tabview_private.h
    ../lvgl/src/widgets/textarea/: lv_textarea.c lv_textarea.h lv_textarea_private.h
    ../lvgl/src/widgets/tileview/: lv_tileview.c lv_tileview.h lv_tileview_private.h
    ../lvgl/src/widgets/win/: lv_win.c lv_win.h lv_win_private.h
  group LVGL_PORT
    ../lvgl/porting/: lv_port_disp.c lv_port_indev.c touch_coordinate_map.c
  group LVGL_GUI
    ../lvgl_GUI/generated/: gg_pinyin_dict.c events_init.c gui_guider.c setup_scr_DeskTop.c setup_scr_lock_screen.c setup_scr_screen_camera.c setup_scr_screen_calculator.c setup_scr_screen_piano.c setup_scr_screen_drawing.c setup_scr_screen_navigation_bar.c setup_scr_screen_notes.c setup_scr_screen_Signal_Proc.c setup_scr_screen_yuanshen.c widgets_init.c setup_scr_screen_image_viewer.c setup_scr_screen_avi_player.c setup_scr_screen_music.c
    ../lvgl_GUI/custom/: custom.c boot_progress_ui.c image_viewer_ui.c music_player_ui.c music_player_visual.c drawing_app_ui.c nes_player_ui.c selection_textarea_adapter.c selection_keyboard_maps.c selection_keyboard.c notes_editor_refresh_guard.c notes_editor_selection_target.c notes_editor_ui.c font_bridge.c font_cache_lvgl.c font_cache_lvgl_load.c
    ../lvgl_GUI/generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_14.c lv_font_montserratMedium_16.c lv_font_montserratMedium_18.c lv_font_montserratMedium_20.c lv_font_montserratMedium_30.c
  group LVGL_IMG
    ../lvgl_GUI/generated/images/: _alarm_RGB565A8_80x80.c _calculator_RGB565A8_80x80.c _draw_RGB565A8_80x80.c _piano_RGB565A8_80x80.c _steam_RGB565A8_80x80.c _calendar_RGB565A8_80x80.c _camera_RGB565A8_80x80.c _Edge_RGB565A8_80x80.c _fingerprint_RGB565A8_70x70.c _folder_RGB565A8_80x80.c _message_RGB565A8_80x80.c _note_RGB565A8_80x80.c _phone_RGB565A8_80x80.c _photo_album_RGB565A8_80x80.c _setting_RGB565A8_80x80.c _weather_RGB565A8_80x80.c _yuanshen_RGB565A8_80x80.c _music_RGB565A8_80x80.c
    ../lvgl_GUI/custom/: music_demo_assets.c
  group Application_Services
    ../Core/Application/Src/: app_runtime.c storage_service.c image_viewer_app.c camera_preview_service.c camera_ui_bridge.c nand_scan_service.c boot_probe_service.c boot_progress_service.c music_player_service.c system_settings_service.c calculator_engine.c calculator_controller.c drawing_history.c drawing_bmp_writer.c piano_synth.c piano_audio_service.c piano_touch_mapper.c nes_input.c nes_controller_port.c nes_audio_service.c nes_player_controls.c nes_rom.c nes_video.c nes_runtime.c nes_platform.c nes_rom_catalog.c nes_core_runtime.c nes_core_engine.c notes_utf8_internal.c notes_document.c notes_storage_codec.c notes_storage_platform.c notes_storage_service.c text_selection_controller.c boot_probe_targets.c boot_report_service.c font_cache_blob.c font_cache_blob_load.c font_cache_service.c font_cache_service_platform.c font_cache_source.c nand_cache_layout.c nand_cache_metadata.c nand_cache_page.c nand_cache_slot.c nand_cache_store.c nand_cache_store_stream.c nand_page_ecc.c file_manager_path.c file_manager_service.c file_manager_copy.c file_manager_tree.c file_manager_delete.c file_manager_directory.c file_manager_operations.c file_manager_platform.c wav_playback_service.c drawing_bmp_reader.c
    ../lvgl_GUI/custom/: file_manager_ui.c file_open_router.c
  group Oscilloscope
    ../Core/Application/Src/: oscilloscope_session.c oscilloscope_workspace.c oscilloscope_zoom.c oscilloscope_storage.c oscilloscope_core.c oscilloscope_accurate.c scope_reference_dsp.c scope_reference_frequency.c
    ../lvgl_GUI/custom/: oscilloscope_ui.c oscilloscope_controls.c oscilloscope_files.c
    ../Core/Peripheral/Src/: oscilloscope_timing.c oscilloscope_phy.c oscilloscope_driver.c
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c
  group NES_Core
    ../Core/Middlewares/NES/: nes_core_arena.c nes_ppu_output.c nes_ppu.c nes_apu.c nes_mapper.c 6502.s
  group Peripheral_Drivers
    ../Core/Peripheral/Src/: board_i2c.c adc_measurement_service.c tpad_service.c ir_remote_service.c sh3001_service.c imu_service.c st480mc_service.c pressure_service.c ap3216c_service.c at24c02_service.c command_parser.c jpegcodec.c ltdc_video_output.c norflash.c pcf8574.c sdcard_manager.c sccb.c ov5640_registers.c ov5640_service.c camera_resource_service.c camera_dcmi_driver.c qspi_drv.c shared_buffer.c resource_manager.c app_event.c diagnostics.c sdcard.c nand_readonly.c nand_cache_io.c es8388_service.c mp3_decoder_service.c avi_audio_decoder.c audio_playback_service.c audio_recording_service.c
    ../Core/Peripheral/MP3/Helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
  group Middlewares
    ../Core/Middlewares/FATFS/: diskio.c ff.c ffunicode.c
    ../Core/Middlewares/MJPEG/: avi.c mjpeg.c
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
software components: CMSIS:CORE 4.3.0
